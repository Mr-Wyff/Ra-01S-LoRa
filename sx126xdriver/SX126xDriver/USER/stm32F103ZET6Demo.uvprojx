# Keil uVision project stm32F103ZET6Demo.uvprojx, settings and files
target myDemo (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32F103ZET6Demo +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\platform\platform_common;..\platform\platform_common\inc;..\hardware;..\platform\platform_HAL\example;..\platform\platform_HAL;..\platform\util;..\SX126xRadio\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group platform_common
    ../platform/platform_common/: common_API.c
    ../platform/platform_common/src/: common.c
  group platform_HAL
    ../platform/platform_HAL/: HAL_common.c HAL_gpio_API.c HAL_uart_API.c HAL_SPI_API.c
    ../platform/util/: my_delay.c
  group example
    ../platform/platform_HAL/example/: example_HAL_gpio_in_out.c example_HAL_uart_init.c example_HAL_spi_init.c example_HAL_gpio_irq.c
  group SX126xRadio
    ../SX126xRadio/src/: crc.c radio.c sx126x.c sx126x-board.c
